Commit message: nav tuned

File: src/fetch/fetch_ros/fetch_description/robots/fetch.urdf.xacro (robot description, xacro)
@@ -9,4 +9,4 @@
         <parent link="fetch_robot_link" />
         <child link="base_link" />
-    </joint> -->
+    </joint>
 </robot>
